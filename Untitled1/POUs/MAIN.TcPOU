PROGRAM MAIN
VAR
	inputEL AT %I*:INT;
	dpState1 AT %I* :USINT;
	dpState2 AT %I* :USINT;
	boolTEST AT %I* :BOOL;
	bool2TEST AT %Q* :BOOL;
END_VAR

END_PROGRAM
